## boards/shields/bault_dongle/Kconfig.shield
```kconfig
# No whitespace after the comma or in the keyboard name!
config bault_dongle
    def_bool $(shields_list_contains,bault_dongle)
```
